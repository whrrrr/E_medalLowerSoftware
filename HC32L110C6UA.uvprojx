# Keil uVision project HC32L110C6UA.uvprojx, settings and files
target wsd (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: HC32L110C6UA +hex
  c flags: Optim=4 oTime=1
  c include: .\common;.\source;.\driver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group common
    ./common/: system_hc32l110c6ua.c
    ./: startup_hc32l110c6ua.s
  group source
    ./source/: main.c epd.c draw.c queue.c uart_interface.c e104.c w25q32.c flash_manager.c global_buffers.c image_display_new.c image_transfer_manager.c crc_utils.c
  group driver
    ./driver/src/: uart.c clk.c ddl.c bt.c interrupts_hc32l110.c gpio.c lpuart.c i2c.c spi.c lpm.c lpt.c
software components: CMSIS:CORE 4.1.0
